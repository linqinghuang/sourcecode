# Keil uVision project Test602.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: Test602
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Test602.c
